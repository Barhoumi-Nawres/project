
DESCRIPTION = "A production image"

LICENSE= "CLOSED"

inherit core-image

